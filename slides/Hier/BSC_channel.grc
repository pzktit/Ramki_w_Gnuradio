options:
  parameters:
    author: pzawadzki
    generate_options: hb
    id: bsc_channel
    output_language: python
    title: BSC Bit Channel
  states: {}

blocks:
- name: BER
  id: parameter
  parameters:
    label: 'BER [%]:'
    type: eng_float
    value: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: BER/100
    type: float
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: i2f_a_0
  id: blocks_int_to_float
  parameters:
    scale: '-(2.0**16-1)'
  states: {}
- name: in
  id: pad_source
  parameters:
    label: bits_in
    type: byte
  states: {}
- name: out
  id: pad_sink
  parameters:
    label: bits_out
    type: byte
  states: {}
- name: rand_num_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 2**16
    minimum: '0'
    seed: '0'
    type: int
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_xor_xx_0, '0', out, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_0, '1']
- [i2f_a_0, '0', blocks_add_const_vxx_0, '0']
- [in, '0', blocks_xor_xx_0, '0']
- [rand_num_0, '0', i2f_a_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
