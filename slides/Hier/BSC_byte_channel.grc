options:
  parameters:
    author: pzawadzki
    generate_options: hb
    id: bsc_byte_channel
    output_language: python
    title: BSC Byte Channel
  states: {}

blocks:
- name: BER
  id: parameter
  parameters:
    label: 'BER [%]:'
    type: eng_float
    value: '0'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      MSB (network) bit order,
      update "packet_len" tag
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      MSB (network) bit order,
      update "packet_len" tag
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: len_key
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: bits
    type: byte
  states: {state: disabled}
- name: bsc_channel_0
  id: bsc_channel
  parameters:
    BER: BER
  states: {}
- name: in
  id: pad_source
  parameters:
    label: byts_in
    type: byte
  states: {}
- name: len_key
  id: parameter
  parameters:
    label: 'Length tag name:'
    type: str
    value: '"packet_len"'
  states: {}
- name: out
  id: pad_sink
  parameters:
    label: bytes_out
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_repack_bits_bb_0, '0', bsc_channel_0, '0']
- [blocks_repack_bits_bb_0_0, '0', out, '0']
- [bsc_channel_0, '0', blocks_repack_bits_bb_0_0, '0']
- [in, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
