options:
  parameters:
    author: pzawadzki
    description: Prepends data with a header. Input- message, Output - tagged stream of bytes
    generate_options: hb
    id: header_prepend
    output_language: python
    title: Header Prepend
  states: {}

blocks:
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: len_key
    ninputs: '2'
    type: byte
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: header_formatter_obj
  states: {}
- name: header_formatter_obj
  id: parameter
  parameters:
    label: 'Header formatter Obj.:'
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 0,1)
  states: {}
- name: len_key
  id: parameter
  parameters:
    label: 'Length tag name:'
    type: str
    value: '"packet_len"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: bytes_out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdu_in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}

connections:
- [blocks_tagged_stream_mux_0, '0', pad_sink_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pad_source_0, out, digital_protocol_formatter_async_0, in]
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
