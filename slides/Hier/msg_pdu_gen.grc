options:
  parameters:
    author: pzawadzki
    description: Periodically generate PDUs with textual content that can be changed at runtime
    generate_options: hb_qt_gui
    id: msg_pdu_gen
    output_language: python
    title: QT GUI Message PDU Gen
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: 'Delay [ms]:'
    rangeType: int
    start: '100'
    step: '100'
    stop: '10000'
    value: '2000'
    widget: eng
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      autopowtarzanie
      komunikatu
    msg: 'pmt.intern(b"") '
    period: delay
  states: {}
- name: lambda1
  id: pdu_pdu_lambda
  parameters:
    comment: Msg2PDU
    fn: 'lambda msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(pmt.symbol_to_string(msg)), [ord(i) for i in pmt.symbol_to_string(msg)]))'
    key: ''
    metadict: Raw Message
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdus_out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: text_in
    optional: 'True'
    type: message
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Treść nadawanego komunikatu
    is_pair: 'False'
    label: Enter message and press enter
    type: string
    value: Akuku, tu pilny student!
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lambda1, pdu]
- [lambda1, pdu, pad_sink_0, in]
- [pad_source_0, out, qtgui_edit_box_msg_0, val]
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
