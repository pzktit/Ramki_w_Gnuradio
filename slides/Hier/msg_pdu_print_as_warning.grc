options:
  parameters:
    author: pzawadzki
    description: Signal warning and print the textual content of the pdu
    generate_options: hb
    id: msg_pdu_print_as_warning
    output_language: python
    title: PDU warn
  states: {}

blocks:
- name: lambda1_0_0
  id: pdu_pdu_lambda
  parameters:
    comment: pmt.u8vector to pmt.string
    fn: 'lambda u8vector: pmt.intern(''''.join(chr(x) for x in pmt.u8vector_elements(u8vector)).encode())'
    key: ''
    metadict: Raw Message
  states: {}
- name: log_a_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdus_in
    type: message
  states: {}
- name: pdu_pdu_split_0_0
  id: pdu_pdu_split
  parameters:
    pass_empty: 'True'
  states: {}

connections:
- [lambda1_0_0, pdu, log_a_0_0_0, log]
- [pad_source_0, out, pdu_pdu_split_0_0, pdu]
- [pdu_pdu_split_0_0, vec, lambda1_0_0, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
