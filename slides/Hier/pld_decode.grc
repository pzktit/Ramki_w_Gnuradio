options:
  parameters:
    author: pzawadzki
    description: Extracts raw payload from FEC and CRC protected PDU
    generate_options: hb
    id: pld_decode
    output_language: python
    title: Payload Decode
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: payload_key
  states: {}
- name: digital_crc_check_1
  id: digital_crc_check
  parameters:
    comment: Discard CRC - True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: fec_decoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: fec_decoder_obj
  id: parameter
  parameters:
    label: 'FEC decoder Obj.:'
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ok
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: fail
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: bytes_in
    type: byte
  states: {}
- name: payload_key
  id: parameter
  parameters:
    label: 'Length tag name:'
    type: str
    value: '"payload symbols"'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: payload_key
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_map_bb_0, '0']
- [digital_crc_check_1, fail, pad_sink_0_0, in]
- [digital_crc_check_1, ok, pad_sink_0, in]
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [fec_async_decoder_0, out, digital_crc_check_1, in]
- [pad_source_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
