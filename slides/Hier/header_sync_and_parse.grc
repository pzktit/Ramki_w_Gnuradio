options:
  parameters:
    author: pzawadzki
    description: Syncs to MSB bitstream. Interprets header fields and outputs payload as tagged bytestream.
    generate_options: hb
    id: header_sync_and_parse
    output_language: python
    title: Header Sync & Parse
  states: {}

blocks:
- name: access_code
  id: parameter
  parameters:
    label: 'Access Code:'
    type: str
    value: digital.packet_utils.default_access_code
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(access_code)
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      bits here are in 
      MSB (network) order,
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: len_key
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: byte
    share_type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    tagname: '"frame start"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: |-
      header_format_default and header_format_counter
      use message "payload symbols" to pass
      the length of the payload. Use that as Length tag key.

      Please use apriopriate setting for "payload_key" variable.
    header_len: hdr_format_obj.header_nbits()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: len_key
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: ()
    timing_tag_key: ''
    trigger_tag_key: '"frame start"'
    type: byte
  states: {}
- name: digital_protocol_parser_b_0_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format_obj
  states: {}
- name: hdr_format_obj
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 0,1)
  states: {}
- name: len_key
  id: parameter
  parameters:
    label: 'Payload Length Tag:'
    type: str
    value: '"payload symbols"'
  states: {}
- name: note_2
  id: note
  parameters:
    comment: Blok synchronizacji i parsowania nagłówka pakietu.
    note: Co to jest?
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: bytes_out
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: header_bits
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: header_data
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: msb_bits_in
    type: byte
  states: {}

connections:
- [blocks_delay_0, '0', blocks_tag_share_0, '0']
- [blocks_repack_bits_bb_0_0, '0', pad_sink_0, '0']
- [blocks_tag_share_0, '0', digital_header_payload_demux_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_share_0, '1']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0_0, '0']
- [digital_header_payload_demux_0, '0', pad_sink_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_0_0, '0']
- [digital_protocol_parser_b_0_0, info, digital_header_payload_demux_0, header_data]
- [digital_protocol_parser_b_0_0, info, pad_sink_0_0_0, in]
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', digital_correlate_access_code_tag_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
