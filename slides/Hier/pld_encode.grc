options:
  parameters:
    author: pzawadzki
    description: Adds CRC and FEC layer to raw payload data
    generate_options: hb
    id: pld_encode
    output_language: python
    title: Payload Encode
  states: {}

blocks:
- name: digital_crc_append_1
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: fec_encoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: fec_encoder_obj
  id: parameter
  parameters:
    label: 'FEC encoder Obj.:'
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdu_out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdu_in
    type: message
  states: {}

connections:
- [digital_crc_append_1, out, fec_async_encoder_0, in]
- [fec_async_encoder_0, out, pad_sink_0, in]
- [pad_source_0, out, digital_crc_append_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
