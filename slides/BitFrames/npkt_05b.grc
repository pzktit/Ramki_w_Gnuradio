options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_05b
    output_language: python
    title: advanced header/payload separation 1 of 2
  states: {}

blocks:
- name: fec_decoder_obj
  id: variable_cc_decoder_def
  parameters:
    comment: Cyclic encoder
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: fec_decoder_obj
  id: variable_dummy_decoder_def
  parameters:
    comment: Dummy code - no additional protection
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_repetition_decoder_def
  parameters:
    comment: Simple repetition code
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: fec_encoder_obj
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: frame_key
  id: variable
  parameters:
    value: len_key
  states: {}
- name: fs
  id: variable
  parameters:
    comment: bit = 1us
    value: 1000000/8
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: rx_format_obj
  id: variable
  parameters:
    value: digital.header_format_crc(len_key,num_key)
  states: {}
- name: tx_format_obj
  id: variable
  parameters:
    value: digital.header_format_crc(len_key,num_key)
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      format_header_crc used by
      Protocol Parser expects stream 
      of bits in machine order.
      LSB used here.
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_repack_bits_bb_0_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: frame_key tag and LSB used here.
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: frame_key
  states: {}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: wyjście
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: len_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: blocks_uchar_to_float_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: bsc_byte_channel_0
  id: bsc_byte_channel
  parameters:
    BER: '0'
    len_key: len_key
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: |-
      header_format_crc uses "packet_len" 
      to mark data on payload output.

      header_format_default and header_format_counter
      use message "payload symbols" to pass
      the length of the payload. Use that as Length tag key.

      Please use apriopriate setting for "frame_key" variable.
    header_len: tx_format_obj.header_nbits()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: frame_key
    output_symbols: 'True'
    samp_rate: int(fs)
    special_tags: ()
    timing_tag_key: ''
    trigger_tag_key: len_key
    type: byte
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: tx_format_obj
  states: {}
- name: digital_protocol_parser_b_0_0
  id: digital_protocol_parser_b
  parameters:
    format: tx_format_obj
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Please select one of the offerered 
      FEC protection variants by
      enablig/disabling the group of blocks
      that define objects used by 
      the encoder/decoder blocks.
    note: Please select FEC
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      Klasy wykorzystujące access_code do synchronizacji początku nagłówka wymagają
      strumienia bitów MSB i takie nastawy powinny być w RepackBits. Podczas parsowania
      pakietu do demuxera wystawiana jest długość pola danych (payload) w znaczniku
      "payload symbols" i taka wartośc powinna być  użyta w parametrze "Length tag key:" 
      demuxera HPD.

      Z kolei "format_header_crc" wymaga strumienia bitów w trybie LSB (a może natwynym
      maszyny). Długość pola danych jest wystawiana w znaczniku "packet_len" i taki powinien
      być ustawiony w HPL.

      Długość nagłówka w bitach można pobrać z klasy formattera korzystając z metody 
      header_nbits(), np. "hdr_format_tx.header_nbits()".
    note: Niezgodności formatowania nagłówków
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      Złożone struktury nagłówków mogą być analizowane z wykorzystaniem klas
      wyprowadzonych z digital.header_format_base. Klasa demuxera może pracować 
      na poziomie symboli dzięki czemu możliwa jest właściwa interpretacja systemów,
      w których nagłówki są inaczej modulowane niż pole danych (vide OFDM).

      W przykładzie wykorzystano klasę digital.header_format_crc. Block 
      Header/Payload demux wymaga aby zgrubna synchronizacja była wykonana na zewnątrz bloku.
      W przykładzie pominięto ten element - synchornizację zapewnia znacznik packet_len.

      Klasa "format_header_crc" wymaga strumienia bitów w trybie LSB (a może natwynym
      maszyny). Długość pola danych jest wystawiana w znaczniku "packet_len" i taki powinien
      być ustawiony w HPL.

      Długość nagłówka w bitach można pobrać z klasy formattera korzystając z metody 
      header_nbits(), np. "hdr_format_tx.header_nbits()".
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pld_decode_0
  id: pld_decode
  parameters:
    fec_decoder_obj: fec_decoder_obj
    payload_key: frame_key
  states: {}
- name: pld_encode_0
  id: pld_encode
  parameters:
    fec_encoder_obj: fec_encoder_obj
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    name: '"Header"'
    size: tx_format_obj.header_nbits()
    srate: fs
    stemplot: 'True'
    tr_tag: ''
    type: float
    ylabel: '""'
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: received_bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: received_bytes
  states: {}

connections:
- [blocks_repack_bits_bb_0_1_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0_1_0_0, '0', pld_decode_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_tagged_stream_mux_0, '0', bsc_byte_channel_0, '0']
- [blocks_uchar_to_float_1_0_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [bsc_byte_channel_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '0', blocks_uchar_to_float_1_0_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_0_1_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_tag_debug_0_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_parser_b_0_0, info, blocks_message_debug_0_0_0_0_0_0, log]
- [digital_protocol_parser_b_0_0, info, digital_header_payload_demux_0, header_data]
- [msg_pdu_gen_0, pdus_out, pld_encode_0, pdu_in]
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pld_decode_0, fail, msg_pdu_print_as_error_0, pdus_in]
- [pld_decode_0, ok, msg_pdu_print_0, pdus_in]
- [pld_encode_0, pdu_out, digital_protocol_formatter_async_0, in]
- [virtual_source_1, '0', blocks_repack_bits_bb_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
