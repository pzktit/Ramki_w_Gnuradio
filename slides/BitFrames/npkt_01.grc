options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_01
    output_language: python
    title: Send message via BSC channel
  states: {}

blocks:
- name: BER
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fs
  id: variable
  parameters:
    comment: 1 bit lasts 1us
    value: 1000000//8
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: len_key
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: bytes
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: bsc_channel_0
  id: bsc_channel
  parameters:
    BER: BER
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Do procesu komunikacji wprowadzono kanał BSC.
      Można obserwować wpływ stopy błędów na jakość
      przesyłanych komunikatów.
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', bsc_channel_0, '0']
- [blocks_repack_bits_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [bsc_channel_0, '0', blocks_repack_bits_bb_0_0, '0']
- [msg_pdu_gen_0, pdus_out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, msg_pdu_print_0, pdus_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
