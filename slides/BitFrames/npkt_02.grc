options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_02
    output_language: python
    title: Detection of transmission errors
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    comment: |-
      Przy takim próbkowaniu
      jeden bit trwa 1us.
    value: 1000000/8
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: bytes
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      throttle jest obowiązkowe
      gdy nie ma sprzętowych
      odbiorników/nadajników.
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: bsc_byte_channel_0
  id: bsc_byte_channel
  parameters:
    BER: '1'
    len_key: len_key
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Skip CRC - True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Proces komunikacji uzupełniono o mechanizm
      wykrywania błędów transmisji. Po stronie nadawczej 
      dane są uzupełniane o sumę kontrolną CRC32, 
      która jest sprawdzana po stronie odbiorczej,
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: len_key
    type: byte
  states: {}

connections:
- [bsc_byte_channel_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_crc_check_0, fail, msg_pdu_print_as_error_0, pdus_in]
- [digital_crc_check_0, ok, msg_pdu_print_0, pdus_in]
- [msg_pdu_gen_0, pdus_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', bsc_byte_channel_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
