options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_00
    output_language: python
    title: 'Periodically generate and print messages '
  states: {}

blocks:
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Nadajnik i odbiornik "zwarte" na krótko.
      Nadajnik okresowo produkuje wiadomości,
      które są następnie drukowane.
    note: Co to jest?
  states: {}

connections:
- [msg_pdu_gen_0, pdus_out, msg_pdu_print_0, pdus_in]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
