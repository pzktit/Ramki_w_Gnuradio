options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_03
    output_language: python
    title: Correction of transmission errors
  states: {}

blocks:
- name: fec_decoder_obj
  id: variable_cc_decoder_def
  parameters:
    comment: Cyclic encoder
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_dummy_decoder_def
  parameters:
    comment: Dummy code - no additional protection
    framebits: '8000'
    ndim: '0'
  states: {}
- name: fec_decoder_obj
  id: variable_repetition_decoder_def
  parameters:
    comment: Simple repetition code
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {}
- name: fs
  id: variable
  parameters:
    comment: bit = 1us
    value: 1000000/8
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {state: disabled}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: variable_ldpc_encoder_def_0
  id: variable_ldpc_encoder_def
  parameters:
    ndim: '0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      FEC Async decoder works on
      stream of soft bits ("0"->-1), 
      bits ordered in machine order,
      i.e. LSB for typical PC's
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: bsc_byte_channel_0
  id: bsc_byte_channel
  parameters:
    BER: '1'
    len_key: len_key
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters: {}
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Skip CRC - True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: fec_decoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: fec_encoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Please select one of the offerered 
      FEC protection variants by
      enablig/disabling the group of blocks
      that define objects used by 
      the encoder/decoder blocks.
    note: Please select FEC
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Przy stopie błędów 1/% w zasadzie każda ramka jest błędna.
      Aby temu zaradzić wprodzono stopień korekcji błędów. Bloki
      kodera i dekodera do kodowania nadmiarowego wykorzystują
      klasy definiujące określony kod. Po lewej zdefiono trzy warianty: 
      Dummy - brak ochrony,
      Repetition - kod powtórzeniowy, 
      CC - kod cykliczny.

      Aktywacja każdego z wariantów polega na wyłączeniu pozostałych dwóch.
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_map_bb_0, '0']
- [bsc_byte_channel_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_crc_append_0, out, fec_async_encoder_0, in]
- [digital_crc_check_0, fail, msg_pdu_print_as_error_0, pdus_in]
- [digital_crc_check_0, ok, msg_pdu_print_0, pdus_in]
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [fec_async_decoder_0, out, digital_crc_check_0, in]
- [fec_async_encoder_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [msg_pdu_gen_0, pdus_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', bsc_byte_channel_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
