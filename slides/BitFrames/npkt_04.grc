options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_04
    output_language: python
    title: simplistic frame synchronization and payload/header demuxing
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: fec_decoder_obj
  id: variable_cc_decoder_def
  parameters:
    comment: Cyclic encoder
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_dummy_decoder_def
  parameters:
    comment: Dummy code - no additional protection
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_repetition_decoder_def
  parameters:
    comment: Simple repetition code
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: fec_encoder_obj
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: fec_encoder_obj
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: frame_key
  id: variable
  parameters:
    value: '"frame start"'
  states: {}
- name: fs
  id: variable
  parameters:
    comment: bit = 1us
    value: 1000000/8
  states: {}
- name: hdr_format_obj
  id: variable_header_format_default
  parameters:
    access_code: '"1010110011011101101001001110001011110010100011000010000011111100"'
    bps: '1'
    threshold: '0'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {state: disabled}
- name: payload_key
  id: variable
  parameters:
    value: '"payload symbols"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {state: disabled}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      MSB (network) bit order,
      update "packet_len" tag
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      bits here are in 
      MSB (network) order,
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: payload_key
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      we need to repack them to
      LSB order to fullfil
      the requirements of FEC Decoder
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: payload_key
  states: {}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: header bits
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: demuxed payload stream
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: len_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_1
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Prepend and append some
      random bits to the packet
    lengthtagname: len_key
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: blocks_uchar_to_float_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: bsc_channel_0
  id: bsc_channel
  parameters:
    BER: '0'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    comment: See the "Correlate access code" note.
    tagname: frame_key
    threshold: '1'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: payload_key
    threshold: '2'
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Skip CRC - True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format_obj
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: fec_decoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: fec_encoder_obj
    mtu: '1500'
    packed: 'True'
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Please select one of the offerered 
      FEC protection variants by
      enablig/disabling the group of blocks
      that define objects used by 
      the encoder/decoder blocks.
    note: Please select FEC
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      Klasy wykorzystujące access_code do synchronizacji początku nagłówka wymagają
      strumienia bitów MSB i takie nastawy powinny być w RepackBits. Podczas parsowania
      pakietu do demuxera wystawiana jest długość pola danych (payload) w znaczniku
      "payload symbols" i taka wartośc powinna być  użyta w parametrze "Length tag key:" 
      demuxera HPD. Bity w "out payload" też mają kolejność MSB.

      Długość nagłówka w bitach można pobrać z klasy formattera korzystając z metody 
      header_nbits(), np. "hdr_format_tx.header_nbits()".
    note: Niezgodności formatowania nagłówków
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Uproszczona wersja synchronizacji ramki i interpretacji nagłówka.

      Standardowy obiekt formatowania ramki dodaje zadany kod 
      synchronizacji oraz nagłówek zawierający długość pola danych 
      (dwie potórzone liczby 16-bitowe). Zadaniem bloków "Correlate ..."
      jest złapanie synchronizazji z dodaną sekwencją bitową (kodem Barkera). 

      Code-tag znakuje pierwszą próbkę po złapaniu synchronizacji.
      Dlasza analiza musi być wykonana samodzielnie w zależności
      od zaimplementowanego protokołu.

      Code - Tag Stream współpracuje z domyślnym formatem nagłówka - 
      długość pola danych zapisana dwukrotnie jako dwie 16-bitowe liczby.
      Pola te są interpretowane i ustawiany jest znacznik na pierwszej próbce
      pola danych zawierający jego długość.

      Obsługa bardziej zaawansowanych nagłówków wymaga zdefiniowania 
      własnego bloku. Metoda nie współdziała ze schematami w których 
      synchronizacja zgrubna jest łapana na poziomie symboli.
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: payload_key
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    name: '"Header"'
    size: hdr_format_obj.header_nbits()-len(access_code)
    srate: fs*8
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: frame_key
    type: float
    ylabel: '""'
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: rand_bitstream_0
  id: rand_bitstream
  parameters:
    len_key: len_key
    length: '10'
  states: {}
- name: rand_bitstream_0_0
  id: rand_bitstream
  parameters:
    len_key: len_key
    length: '15'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: received_bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: |-
      See note. Input from bitwise
      BSC channel with apriopriate
      byte to bit mappings.
    stream_id: received_bits
  states: {}

connections:
- [blocks_char_to_float_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0, '0', bsc_channel_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_map_bb_0, '0']
- [blocks_tag_gate_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_tag_gate_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_tagged_stream_mux_1, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_1_0_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [bsc_channel_0, '0', blocks_tagged_stream_mux_1, '1']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0_0_0_0_0, '0']
- [digital_crc_append_0, out, fec_async_encoder_0, in]
- [digital_crc_check_0, fail, msg_pdu_print_as_error_0, pdus_in]
- [digital_crc_check_0, ok, msg_pdu_print_0, pdus_in]
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [fec_async_decoder_0, out, digital_crc_check_0, in]
- [fec_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [msg_pdu_gen_0, pdus_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]
- [rand_bitstream_0, '0', blocks_tagged_stream_mux_1, '0']
- [rand_bitstream_0_0, '0', blocks_tagged_stream_mux_1, '2']
- [virtual_source_1, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
