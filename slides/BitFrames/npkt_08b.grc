options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_08b
    output_language: python
    title: frame synchronization 2 of 2
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: fec_decoder_obj
  id: variable_cc_decoder_def
  parameters:
    comment: Cyclic encoder
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: fec_decoder_obj
  id: variable_dummy_decoder_def
  parameters:
    comment: Dummy code - no additional protection
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_repetition_decoder_def
  parameters:
    comment: Simple repetition code
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: fec_encoder_obj
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fs
  id: variable
  parameters:
    comment: bit = 1us
    value: 1000000/8
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: rx_format_obj
  id: variable
  parameters:
    value: digital.header_format_counter(access_code, 2,1)
  states: {}
- name: rx_format_obj
  id: variable_header_format_default
  parameters:
    access_code: '"1010110011011101101001001110001011110010100011000010000011111100"'
    bps: '1'
    comment: |-
      Formatter objects have internal state.
      Different instances of the same class
      should be used to format and parse
      packet header.
    threshold: '2'
  states: {state: disabled}
- name: tx_format_obj
  id: variable_header_format_default
  parameters:
    access_code: '"1010110011011101101001001110001011110010100011000010000011111100"'
    bps: '1'
    threshold: '0'
  states: {state: disabled}
- name: tx_format_obj
  id: variable
  parameters:
    comment: |-
      Formatter objects have internal state.
      Different instances of the same class
      should be used to format and parse
      packet header.
    value: digital.header_format_counter(access_code, 0,1)
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      MSB (network) bit order,
      update "packet_len" tag
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_1
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Prepend and append some
      random bits to the packet
    lengthtagname: len_key
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: blocks_uchar_to_float_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: bsc_channel_0
  id: bsc_channel
  parameters:
    BER: '0'
  states: {}
- name: header_prepend_0
  id: header_prepend
  parameters:
    header_formatter_obj: tx_format_obj
    len_key: len_key
  states: {}
- name: header_sync_and_parse_0
  id: header_sync_and_parse
  parameters:
    access_code: access_code
    hdr_format_obj: rx_format_obj
    len_key: '"payload symbols"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Please select one of the offerered 
      FEC protection variants by
      enablig/disabling the group of blocks
      that define objects used by 
      the encoder/decoder blocks.
    note: Please select FEC
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Poprzedni przykład uzupełniony o generację losowych bitów 
      otaczających sekwencje reprezentujące ramki. 

      Celem tego przykładu jest pokazanie, że zastosowana metoda rzeczywiście działa.
    note: Co to jest?
  states: {}
- name: pld_decode_0
  id: pld_decode
  parameters:
    fec_decoder_obj: fec_decoder_obj
    payload_key: '"payload symbols"'
  states: {}
- name: pld_encode_0
  id: pld_encode
  parameters:
    fec_encoder_obj: fec_encoder_obj
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    name: '"Header"'
    size: rx_format_obj.header_nbits()
    srate: fs
    stemplot: 'True'
    tr_tag: ''
    type: float
    ylabel: '""'
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: rand_bitstream_0
  id: rand_bitstream
  parameters:
    len_key: len_key
    length: '10'
  states: {}
- name: rand_bitstream_0_0
  id: rand_bitstream
  parameters:
    len_key: len_key
    length: '15'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: received_bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: |-
      Input from bitwise BSC channel with 
      MSB byte to bits mappings.
    stream_id: received_bits
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', bsc_channel_0, '0']
- [blocks_tag_gate_0, '0', header_sync_and_parse_0, '0']
- [blocks_tagged_stream_mux_1, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_1_0_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [bsc_channel_0, '0', blocks_tagged_stream_mux_1, '1']
- [header_prepend_0, '0', blocks_repack_bits_bb_0, '0']
- [header_prepend_0, '0', blocks_throttle2_0, '0']
- [header_sync_and_parse_0, '0', pld_decode_0, '0']
- [header_sync_and_parse_0, '1', blocks_uchar_to_float_1_0_0, '0']
- [header_sync_and_parse_0, header_data, blocks_message_debug_0_0_0_0_0_0, log]
- [msg_pdu_gen_0, pdus_out, pld_encode_0, pdu_in]
- [pld_decode_0, fail, msg_pdu_print_as_error_0_0, pdus_in]
- [pld_decode_0, ok, msg_pdu_print_0_0, pdus_in]
- [pld_encode_0, pdu_out, header_prepend_0, pdu_in]
- [rand_bitstream_0, '0', blocks_tagged_stream_mux_1, '0']
- [rand_bitstream_0_0, '0', blocks_tagged_stream_mux_1, '2']
- [virtual_source_1, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
