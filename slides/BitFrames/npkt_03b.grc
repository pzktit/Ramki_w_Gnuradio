options:
  parameters:
    author: pzawadzki
    generate_options: qt_gui
    id: npkt_03b
    output_language: python
    title: Protection of payload data
  states: {}

blocks:
- name: fec_decoder_obj
  id: variable_cc_decoder_def
  parameters:
    comment: Cyclic encoder
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_dummy_decoder_def
  parameters:
    comment: Dummy code - no additional protection
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fec_decoder_obj
  id: variable_repetition_decoder_def
  parameters:
    comment: Simple repetition code
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: fec_encoder_obj
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {state: disabled}
- name: fec_encoder_obj
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: fec_encoder_obj
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: fs
  id: variable
  parameters:
    comment: bit = 1us
    value: 1000000/8
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {state: disabled}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: fs
    samples_per_second: fs
    type: byte
  states: {}
- name: bsc_byte_channel_0
  id: bsc_byte_channel
  parameters:
    BER: '1'
    len_key: len_key
  states: {}
- name: msg_pdu_gen_0
  id: msg_pdu_gen
  parameters: {}
  states: {}
- name: msg_pdu_print_0
  id: msg_pdu_print
  parameters: {}
  states: {}
- name: msg_pdu_print_as_error_0
  id: msg_pdu_print_as_error
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Please select one of the offerered 
      FEC protection variants by
      enablig/disabling the group of blocks
      that define objects used by 
      the encoder/decoder blocks.
    note: Please select FEC
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Przy stopie błędów 1/% w zasadzie każda ramka jest błędna.
      Aby temu zaradzić wprodzono stopień korekcji błędów. Bloki
      kodera i dekodera do kodowania nadmiarowego wykorzystują
      klasy definiujące określony kod. Po lewej zdefiono trzy warianty: 
      Dummy - brak ochrony,
      Repetition - kod powtórzeniowy, 
      CC - kod cykliczny.

      Tym razem ochronę pola danych zorganizowano w postaci wydzielonych bloków.

      Aktywacja każdego z wariantów polega na wyłączeniu pozostałych dwóch.
    note: Co to jest?
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pld_decode_0
  id: pld_decode
  parameters:
    fec_decoder_obj: fec_decoder_obj
    payload_key: len_key
  states: {}
- name: pld_encode_0
  id: pld_encode
  parameters:
    fec_encoder_obj: fec_encoder_obj
  states: {}

connections:
- [bsc_byte_channel_0, '0', pld_decode_0, '0']
- [msg_pdu_gen_0, pdus_out, pld_encode_0, pdu_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', bsc_byte_channel_0, '0']
- [pld_decode_0, fail, msg_pdu_print_as_error_0, pdus_in]
- [pld_decode_0, ok, msg_pdu_print_0, pdus_in]
- [pld_encode_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
